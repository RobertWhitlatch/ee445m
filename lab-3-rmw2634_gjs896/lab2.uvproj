# Keil uVision project lab2.uvproj, settings and files
target lab2 (ARM-ADS)
  device: TM4C1231C3PM Texas Instruments
  cpu: IRAM(0x20000000-0x20002FFF) IROM(0-0x7FFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: lab2
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c misc: --C99
  c include: .;.\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x3000
  scatter file: project.sct
  link misc: --entry Reset_Handler
  group Source
    ./src/: startup.s PLL.c OS.c osasm.s main.c ADC.c ST7735.c String_Ops.c Commands.c Output.c cr4_fft_64_stm32.s PID_stm32.s GPIO.c Timers.c OS_PeriodicThreads.c Lab3.c PriorityQueue.c Jitter.c OS_Semaphore.c Interpreter.c
